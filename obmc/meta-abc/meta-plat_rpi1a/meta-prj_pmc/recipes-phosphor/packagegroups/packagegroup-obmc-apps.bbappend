RDEPENDS:${PN}-extras:append = " \
    phosphor-power-control \
    phosphor-power-utils \
    phosphor-power \
    phosphor-power-regulators \
    phosphor-power-psu-monitor \
    \
    dbus-sensors \
    phosphor-sel-logger \
    tzdata-core \
    webui-vue \
"
