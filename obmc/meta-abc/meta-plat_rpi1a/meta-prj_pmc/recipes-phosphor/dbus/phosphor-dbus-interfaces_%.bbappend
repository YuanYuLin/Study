FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

OBMC_ORG_YAML_SUBDIRS += " org/open_power"

SRC_URI:append = " \
"

