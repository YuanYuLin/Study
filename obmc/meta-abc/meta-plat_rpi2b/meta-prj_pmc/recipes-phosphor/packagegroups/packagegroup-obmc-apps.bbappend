RDEPENDS:${PN}-extras:append = " \
    dbus-sensors \
    phosphor-sel-logger \
    tzdata-core \
    webui-vue \
"
